# Keil uVision project JM-CPU.uvprojx, settings and files
target JM-CPU (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: IAP +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o  ..\OBJ\IAP.bin ..\OBJ\IAP.axf
  c flags: Optim=1 OneElfS=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\FWLIB\inc;..\HARDWARE\PWM;..\SYSTEM\usart2;..\SYSTEM\data;..\HARDWARE\LCD;..\HARDWARE\24CXX;..\HARDWARE\I2S;..\HARDWARE\SDIO;..\HARDWARE\SPI;..\HARDWARE\SRAM;..\HARDWARE\WM8978;..\FATFS\src;..\HARDWARE\IIC;..\HARDWARE\W25QXX;..\MALLOC;..\USMART;..\TEXT;..\APP;..\AUDIOCODEC\wav;..\FATFS\exfuns;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\IWDG;..\HARDWARE\power;..\SYSTEM\timer
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/PWM/: PWM.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/I2S/: i2s.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/WM8978/: wm8978.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/WKUP/: wkup.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/power/: power .c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/usart2/: usart2.c
    ../SYSTEM/data/: data.c
    ../SYSTEM/timer/: time.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_fsmc.c stm32f4xx_spi.c stm32f4xx_sdio.c stm32f4xx_dma.c stm32f4xx_rtc.c stm32f4xx_exti.c stm32f4xx_pwr.c stm32f4xx_adc.c stm32f4xx_iwdg.c
  group README
    ../: readme.txt
  group MALLOC
    ../MALLOC/: malloc.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group AUDIOCODEC
    ../AUDIOCODEC/wav/: wavplay.c
  group APP
    ../APP/: audioplay.c
